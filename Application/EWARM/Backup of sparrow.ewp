# IAR project Backup of sparrow.ewp, settings and files
configuration sparrow (ARM, debug)
  General.OGChipSelectEditMenu: STM32WL55JC_M4 ST STM32WL55JC_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: STM32WL55xx; CORE_CM4
  ICCARM.CCIncludePath2: ../; ../Core/Inc; ../App; ../Sensor; ../Core/Radio; ../../note-c; ../../Drivers/STM32WLxx_HAL_Driver/Inc; ../../Drivers/CMSIS/Include; ../../Drivers/CMSIS/Device/ST/STM32WLxx/Include; ../../Middlewares/Third_Party/SubGHz_Phy; ../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver; ../../Utilities/lpm/tiny_lpm; ../../Utilities/misc; ../../Utilities/sequencer; ../../Utilities/timer; ../../Utilities/trace/adv_trace
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sparrow.bin
  ILINK.IlinkOutputFile: sparrow.out
  ILINK.IlinkIcfFile: stm32wl55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App
    ../App/: app.c appinit.c atp.c dfu.c dfuload.c flash.c gateway.c led.c note.c post.c radioinit.c sched.c sensor.c trace.c util.c
  group Application/Core
    ../Core/Src/: debug.c main.c stm32_lpm_if.c stm32wlxx_hal_msp.c stm32wlxx_it.c timer_if.c usart_if.c util_if.c
    ../Core/Radio/: radio_board_if.c
  group Application/EWARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/Gateway
    ../Gateway/: auth.c
  group Application/Sensor
    ../Sensor/: bme.c button.c config.c null.c ping.c pir.c
  group Application/Sensor/bme280
    ../Sensor/bme280/: bme280.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal.c stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_rng.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_spi.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c
  group Middlewares/SubGHz_Phy
    ../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio.c radio_driver.c
  group note-c
    ../../note-c/: n_atof.c n_b64.c n_cjson.c n_cjson_helpers.c n_const.c n_ftoa.c n_helpers.c n_hooks.c n_i2c.c n_md5.c n_request.c n_serial.c n_str.c n_ua.c
  group Utilities
    ../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_vsnprintf.c
    ../../Utilities/sequencer/: stm32_seq.c
    ../../Utilities/timer/: stm32_timer.c
